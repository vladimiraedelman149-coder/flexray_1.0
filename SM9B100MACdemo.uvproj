# Keil uVision project SM9B100MACdemo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: SM9B100MACdemo +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: SM9B100MAC
  c misc: --fpu=vfpv2
  c include: .\APP;.\ARM926EJ-S;.\Source;.\FWlib
  asm define: ARM926EJ_vfpv2
  asm misc: --fpu=vfpv2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x80000 size 0x20000
  memory RVCT10: RAM 0x300000 size 0x1000
  group startup
    ./ARM926EJ-S/: startup_sm9b100.s
  group USR
    ./Source/: main.c sm9b100_it.c
  group FWlib
    ./FWlib/: sm9b100_429.c sm9b100_1553.c sm9b100_1553bc.c sm9b100_1553mt.c sm9b100_1553rt.c sm9b100_boot.c sm9b100_can.c sm9b100_gpio.c sm9b100_i2c.c sm9b100_ictl.c sm9b100_memctl.c sm9b100_spi.c sm9b100_sysc.c sm9b100_tim.c sm9b100_usart.c sm9b100_wdt.c sm9b100_dma.c sm9b100_aes.c sm9b100_pwm.c
  group SM9B100SYS
    ./ARM926EJ-S/: system_sm9b100.c
  group APP
    ./APP/: delay.c debug_usart.c
  group flexray
    ./APP/: flexray.c flexray_conf.c mfr4310.c
